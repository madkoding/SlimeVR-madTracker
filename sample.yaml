## sample.yaml
```yaml
tests:
  common:
    platform_allow:
      - nrf52840dk/nrf52840
      - nrf52840dongle/nrf52840
      - nrf52dk/nrf52832
    sysbuild: true
```
